Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-09-30T13:53:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 30 13:53:24 2019 * Host: ddamian-ro-de * Database: C:\Users\DDamian\AppData\Local\Temp\{C8FA9145-DB72-434D-B166-CFF3CE747D63}\ifc * Database version: 5507 * Database creation date: Mon Sep 30 13:53:22 2019 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Sep 30 13:53:22 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 30 13:53:22 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBoiler: C140-90, HC_Boiler_MEPcontent_De Dietrich Thermique_Elidens_C140 - 90-115_FR-EN:C140-90:1311715
In: V00
Type - PredefinedType: WATER; Material: Color RGB 020-020-020, Color RGB 173-175-175, Color RGB 100-100-100, Color RGB 246-246-246, Color RGB 229-190-001, Color RGB 075-186-252, Color RGB 203-040-033
Type - Dimensions - Depth: 605 mm; Drain Diameter: 22 mm; Flue Gas Diameter: 100 mm; Gas Diameter: 19.05 mm; Height: 1563 mm; Hydronic Return Diameter: 31.75 mm; Hydronic Supply Diameter: 31.75 mm; Supply Air Diameter: 150 mm; Use Nominal Diameter: yes; Width: 600 mm
Type - Electrical - Hertz: 50 Hz; Phase: 1; Voltage: 230 V
Type - Identity Data - Article Description: Floor-standing gas condensing boiler; Article Type: C140-90; Base Family Version: 12.04; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Floor-standing gas condensing boiler; EMCS Version: 4.0; ETIM Article Class: EC011396; Family Version: 12.04; Manufacturer: De Dietrich Thermique; Manufacturer URL: https://www.dedietrich-thermique.fr/; MEPcontent Class: BOILER; Model: C140-90; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Product Line: De Dietrich Thermique; Revit Version: 2017; Type Name: C140-90; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Black: Color RGB 020-020-020; Blue: Color RGB 075-186-252; Grey: Color RGB 100-100-100; Light Grey: Color RGB 173-175-175; Red: Color RGB 203-040-033; White: Color RGB 246-246-246; Yellow: Color RGB 229-190-001
Type - Mechanical - Heat Input G20 (GCV): 1027953; Heat Input G20 (NCV): 925696; Heat Input G25 (GCV): 1027953; Heat Input G25 (NCV): 925696; Heat Input G31 (GCV): 1003196; Heat Input G31 (NCV): 925696
Type - Mechanical - Flow - Nominal Water Flow: 0.001 m3/s
Type - Mechanical - Loads - Maximum Pressure at Nominal Debit (mbar): 4000; Nominal Output (kW): 84.2; Sound Pressure Level dB(A): 45; Unit Weight (kg): 109; Volume: 10.1 m3
Type - Other - Category: Mechanical Equipment; B: 1305 mm; C: 1183 mm; C140-115: no; C140-90: yes; D: 622 mm; E: 352 mm; F: 340 mm; Family Name: HC_Boiler_MEPcontent_De Dietrich Thermique_Elidens_C140 - 90-115_FR-EN; Flue Gas Inside Diameter: 90 mm; Supply Air Inside Diameter: 140 mm
Type - Text - Pipe Type Category: M561
Pset_ManufacturerTypeInformation - Manufacturer: De Dietrich Thermique
Constraints - Offset: 0 mm
Dimensions - Area: 10.6216 m2; Volume: 0.50518 m3
Electrical - Loads - Power: 0 W
Identity Data - Design Option: Main Model; Manufacturer Art. No.: 7709261; Mark: 4
Mechanical - System Classification: Hydronic Supply,Undefined,Hydronic Return,Sanitary,Power,Exhaust Air,Supply Air
Mechanical - Flow - Drain Fixture Units: 0; Flue Gas Flow: 0 m3/s; Gas Flow: 0 m3/s; Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; Supply Air Flow: 0 m3/s
Other - Back Clearance Safe: 500 mm; Family: HC_Boiler_MEPcontent_De Dietrich Thermique_Elidens_C140 - 90-115_FR-EN: C140-90; Family and Type: HC_Boiler_MEPcontent_De Dietrich Thermique_Elidens_C140 - 90-115_FR-EN: C140-90; Feet Offset Safe: 40 mm; Front Clearance Safe: 500 mm; Height Helper: 1603 mm; Left Clearance Safe: 500 mm; Legs Visible: yes; Top Clearance Safe: 500 mm; Type: HC_Boiler_MEPcontent_De Dietrich Thermique_Elidens_C140 - 90-115_FR-EN: C140-90; Type Id: HC_Boiler_MEPcontent_De Dietrich Thermique_Elidens_C140 - 90-115_FR-EN: C140-90
Phasing - Phase Created: 4. Plan over 10 years
Visibility - Back Clearance: 500 mm; Diematic Evolution: yes; Front Clearance: 500 mm; IniControl 2: no; Left Clearance: 500 mm; Legs Height: 40 mm; Service Space: no; Top Clearance: 500 mm
